## drivers/usb/serial/gobiserial/Kconfig
```kconfig
config USB_GOBISERIAL
	tristate "SIMCOM Modem USB Serial driver"
	help
	  usb serial driver for SIMCOM modem
```
